# Keil uVision project uvision_project.uvproj, settings and files
target HelloWorld (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CE3103Lab5 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\library_files\CORE;.\library_files\STM32F1xx_Driver\inc;.\library_files\FreeRTOS\include;.\library_files\FreeRTOS\portable\RVDS\ARM_CM3;.\library_files\SYSTEM\sys;.\library_files\SYSTEM\SYSTEM;.\library_files\SYSTEM\delay;.\library_files\HARDWARE\LED;.\library_files\HARDWARE\OLED;.\library_files\SYSTEM\show;.\library_files\HARDWARE\buzzer;.\library_files\HARDWARE\button;.\library_files\SYSTEM\playsong;.\library_files\HARDWARE\uart
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ./library_files/CORE/: system_stm32f10x.c stm32f10x_it.c core_cm3.c
    ./: startup_stm32f10x_hd.s
  group STM32F1xx_Driver
    ./library_files/STM32F1xx_Driver/src/: stm32f10x_adc.c stm32f10x_dac.c stm32f10x_gpio.c stm32f10x_spi.c misc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ./library_files/SYSTEM/sys/: sys.c
    ./library_files/SYSTEM/SYSTEM/: system.c
    ./library_files/SYSTEM/delay/: delay.c
    ./library_files/SYSTEM/show/: show.c
    ./library_files/SYSTEM/playsong/: playsong.c
  group HARDWARE
    ./library_files/HARDWARE/LED/: LED.C
    ./library_files/HARDWARE/OLED/: oled.c
    ./library_files/HARDWARE/buzzer/: buzzer.c
    ./library_files/HARDWARE/button/: button.c
    ./library_files/HARDWARE/uart/: uart.c
  group FREERTOS
    ./library_files/FreeRTOS/portable/MemMang/: heap_4.c
    ./library_files/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./library_files/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group MAIN
    ./main/: main.c
